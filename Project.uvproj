# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c MAtrix_key.c MAtrix_key.h I2C.h I2C.c SSS.h DS1302.h DS1302.c DS18B02.h DS18B02.c PCF8591.h PCF8591.c
